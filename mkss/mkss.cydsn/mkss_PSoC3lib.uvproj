# Keil uVision project mkss_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: mkss_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x0FFF)) CL(CODE(C:0x0000-C:0x7FFF)) CL(CONST(C:0x0000-C:0x7FFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h UART_Servo.c UART_Servo.h UART_Servo_PM.c UART_Servo_INT.c UART_Servo_BOOT.c UART_Debug.c UART_Debug.h UART_Debug_PM.c UART_Debug_INT.c UART_Debug_BOOT.c UART_PS2.c UART_PS2.h UART_PS2_PM.c UART_PS2_INT.c UART_PS2_BOOT.c ISR_PS2.c ISR_PS2.h UART_Servo_IntClock.c UART_Servo_IntClock.h UART_Debug_IntClock.c UART_Debug_IntClock.h UART_PS2_IntClock.c UART_PS2_IntClock.h cycodeshareimport.ld cycodeshareimport.scat CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h Clock_mkss.c Clock_mkss.h isr_mkss.c isr_mkss.h
target Release (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: mkss_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
